options:
  parameters:
    generate_options: qt_gui
    id: phaser_zmq_host
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: (2/3)*samp_rate
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 10e9
  states: {}
- name: ncpi
  id: variable
  parameters:
    value: '64'
  states: {}
- name: rpi_ip
  id: variable
  parameters:
    value: '"169.254.227.151"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: phaser_sum_beams_0
  id: phaser_sum_beams
  parameters:
    beam_key_pattern: phaser:beam[0-9]+
  states: {}
- name: plasma_lfm_source_0
  id: plasma_lfm_source
  parameters:
    bandwidth: bandwidth
    bandwidth_key: radar:bandwidth
    duration_key: radar:duration
    label_key: core:label
    prf: '0'
    prf_key: radar:prf
    pulse_width: '20e-6'
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    start_freq: '-bandwidth/2'
    start_freq_key: radar:start_freq
  states: {}
- name: plasma_pulse_doppler_0
  id: plasma_pulse_doppler
  parameters:
    backend: plasma.Device.DEFAULT
    depth: '1'
    doppler_fft_size_key: doppler_fft_size
    n_pulse_cpi: ncpi
    nfft: ncpi
  states: {state: disabled}
- name: plasma_range_doppler_sink_0
  id: plasma_range_doppler_sink
  parameters:
    center_freq: center_freq
    center_freq_key: phaser:frequency
    depth: '1'
    detection_indices_key: detection_indices
    dynamic_range: '60'
    dynamic_range_key: dynamic_range
    n_matrix_col_key: n_matrix_col
    nrow: ncpi
    prf_key: phaser:prf
    pulsewidth_key: radar:duration
    samp_rate: samp_rate
    samp_rate_key: core:sample_rate
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: f"tcp://{rpi_ip}:3001"
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: f"tcp://{rpi_ip}:2001"
    bind: 'False'
    timeout: '100'
  states: {}

connections:
- [phaser_sum_beams_0, out, plasma_pulse_doppler_0, rx]
- [phaser_sum_beams_0, out, qtgui_time_sink_x_0, in]
- [plasma_lfm_source_0, out, plasma_pulse_doppler_0, tx]
- [plasma_lfm_source_0, out, qtgui_time_sink_x_0_0, in]
- [plasma_lfm_source_0, out, zeromq_push_msg_sink_0, in]
- [plasma_pulse_doppler_0, out, plasma_range_doppler_sink_0, in]
- [zeromq_pull_msg_source_0, out, phaser_sum_beams_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
