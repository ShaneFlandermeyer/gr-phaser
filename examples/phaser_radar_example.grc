options:
  parameters:
    generate_options: qt_gui
    id: phaser_radar_outline
    output_language: python
    run_command: '{python} {filename}'
    title: Not titled yet
  states: {}

blocks:
- name: angle
  id: variable_qtgui_range
  parameters:
    start: '-45'
    step: '1'
    stop: '45'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.to_pmt([1+1j]*100)
    period: '1000'
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.dict_add(pmt.make_dict(), pmt.intern("angle"), pmt.to_pmt(angle))
    period: '1000'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: phaser_phaser_radar_0
  id: phaser_phaser_radar
  parameters:
    fmcw_if_freq: 100e3
    fmcw_ramp_mode: '''single_sawtooth_burst'''
    fmcw_sweep_bandwidth: 500e6
    fmcw_sweep_duration: '500e-6'
    num_bursts: '10'
    phaser_chan_gain: '[64, 64, 64, 64, 64, 64, 64, 64]'
    phaser_chan_phase: '[0, 0, 0, 0, 0, 0, 0, 0]'
    phaser_output_freq: 10e9
    phaser_uri: ip:phaser.local
    pri: '1e-3'
    radar_mode: '''pulsed'''
    rx_enabled_channels: '[0, 1]'
    rx_gain: '20'
    rx_offset_samps: '61'
    sample_rate: samp_rate
    sdr_freq: 2.1e9
    sdr_uri: ip:pluto.local
    tx_cyclic_buffer: 'True'
    tx_enabled_channels: '[0, 1]'
    tx_hardwaregain_chan0: '-3'
    tx_hardwaregain_chan1: '-3'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    srate: samp_rate
    type: msg_complex
  states: {}

connections:
- [blocks_message_strobe_0, strobe, phaser_phaser_radar_0, in]
- [blocks_message_strobe_0_0, strobe, phaser_phaser_radar_0, in]
- [phaser_phaser_radar_0, out, qtgui_time_sink_x_0, in]

metadata:
  file_format: 1
  grc_version: v3.10.11.0-1-gee27d6f3
