options:
  parameters:
    generate_options: qt_gui
    id: phaser_radar_outline
    output_language: python
    run_command: '{python} {filename}'
    title: Not titled yet
  states: {}

blocks:
- name: angle
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rpi_ip
  id: variable
  parameters:
    value: '"169.254.227.151"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: phaser_phaser_radar_0
  id: phaser_phaser_radar
  parameters:
    burst_start_sample: '0'
    burst_stop_sample: '-1'
    fmcw_if_freq: 100e3
    fmcw_ramp_mode: '''single_sawtooth_burst'''
    fmcw_sweep_bandwidth: 500e6
    fmcw_sweep_duration: '500e-6'
    gain_cal_file: ''
    num_bursts: '32'
    phase_cal_file: ''
    phaser_chan_gain: '[64, 64, 64, 64, 64, 64, 64, 64]'
    phaser_chan_phase: '[0, 0, 0, 0, 0, 0, 0, 0]'
    phaser_output_freq: 10e9
    phaser_uri: ip:phaser.local
    pri: 1/10e3
    radar_mode: '''pulsed'''
    rx_enabled_channels: '[0, 1]'
    rx_gain: '20'
    rx_offset_samples: '102'
    sample_rate: samp_rate
    sdr_freq: 2.1e9
    sdr_uri: ip:pluto.local
    tx_cyclic_buffer: 'True'
    tx_enabled_channels: '[0, 1]'
    tx_hardwaregain_chan0: '-3'
    tx_hardwaregain_chan1: '-3'
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: f"tcp://{rpi_ip}:2001"
    bind: 'True'
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: f"tcp://{rpi_ip}:3001
    timeout: '100'
  states: {}

connections:
- [phaser_phaser_radar_0, out, zeromq_push_msg_sink_0, in]
- [zeromq_pull_msg_source_0, out, phaser_phaser_radar_0, in]

metadata:
  file_format: 1
  grc_version: v3.10.11.0-1-gee27d6f3
