options:
  parameters:
    generate_options: qt_gui
    id: phaser_pulsed
    output_language: python
    run_command: '{python} {filename}'
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 2/3*samp_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: phaser_phaser_radar_0
  id: phaser_phaser_radar
  parameters:
    burst_start_sample: '0'
    burst_stop_sample: '-1'
    fmcw_if_freq: 100e3
    fmcw_ramp_mode: '''single_sawtooth_burst'''
    fmcw_sweep_bandwidth: 500e6
    fmcw_sweep_duration: '500e-6'
    gain_cal_file: ''
    num_bursts: '5'
    phase_cal_file: ''
    phaser_chan_gain: '[127]*8'
    phaser_chan_phase: '[0, 0, 0, 0, 0, 0, 0, 0]'
    phaser_output_freq: 10e9
    phaser_uri: ip:phaser.local
    pri: 1/10e3
    radar_mode: '''pulsed'''
    rx_enabled_channels: '[0, 1]'
    rx_gain: '0'
    rx_offset_samples: '102'
    sample_rate: samp_rate
    sdr_freq: 2.1e9
    sdr_uri: ip:pluto.local
    tx_cyclic_buffer: 'True'
    tx_enabled_channels: '[0, 1]'
    tx_hardwaregain_chan0: '-80'
    tx_hardwaregain_chan1: '0'
  states: {}
- name: phaser_sum_beams_0
  id: phaser_sum_beams
  parameters:
    num_beams_key: phaser:num_beams
  states: {}
- name: plasma_lfm_source_0
  id: plasma_lfm_source
  parameters:
    bandwidth: bandwidth
    bandwidth_key: radar:bandwidth
    duration_key: radar:duration
    label_key: core:label
    prf: '0'
    prf_key: radar:prf
    pulse_width: '20e-6'
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    start_freq: '-bandwidth/2'
    start_freq_key: radar:start_freq
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {}

connections:
- [phaser_phaser_radar_0, out, phaser_sum_beams_0, in]
- [phaser_sum_beams_0, out, qtgui_time_sink_x_0, in]
- [plasma_lfm_source_0, out, phaser_phaser_radar_0, in]

metadata:
  file_format: 1
  grc_version: v3.10.11.0-1-gee27d6f3
