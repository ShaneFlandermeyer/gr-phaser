options:
  parameters:
    generate_options: qt_gui
    id: phaser_zmq_host
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 0.75*samp_rate
  states: {}
- name: rpi_ip
  id: variable
  parameters:
    value: '"169.254.227.151"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30e6
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import re


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
        """Embedded Python Block example - a simple multiply const"""

        def __init__(self, example_param=1.0):  # only default arguments here
          """arguments to this function show up as parameters in GRC"""
          gr.sync_block.__init__(
              self,
              name='Embedded Python Block',   # will show up in GRC
              in_sig=[],
              out_sig=[]
          )
          # if an attribute with the same name as a parameter is found,
          # a callback is registered (properties work, too).
          self.example_param = example_param

          self.message_port_register_in(pmt.intern('in'))
          self.message_port_register_out(pmt.intern('out'))
          self.set_msg_handler(pmt.intern('in'), self.handle_msg)

        def handle_msg(self, msg):
          # Sum the data in phaser:beam0 and phaser:beam1
          meta = msg
          items = pmt.to_python(msg)
          # Sum any items whose key matches the regex
          beam_key_pattern = 'phaser:beam[0-9]+'
          beams = []
          for key, val in items.items():
            if re.match(beam_key_pattern, key):
              beams.append(val)
              meta = pmt.dict_delete(meta, pmt.intern(key))

          # Sum the beams and send to PDU
          data = np.sum(beams, axis=0)
          self.message_port_pub(pmt.intern('out'),
                                pmt.cons(meta, pmt.to_pmt(data)))
    example_param: '1.0'
  states: {}
- name: plasma_lfm_source_0
  id: plasma_lfm_source
  parameters:
    bandwidth: bandwidth
    bandwidth_key: radar:bandwidth
    duration_key: radar:duration
    label_key: core:label
    prf: '0'
    prf_key: radar:prf
    pulse_width: '10e-6'
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    start_freq: '-bandwidth/2'
    start_freq_key: radar:start_freq
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: f"tcp://{rpi_ip}:3001"
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: f"tcp://{rpi_ip}:2001"
    bind: 'False'
    timeout: '100'
  states: {}

connections:
- [epy_block_0, out, qtgui_time_sink_x_0, in]
- [plasma_lfm_source_0, out, zeromq_push_msg_sink_0, in]
- [zeromq_pull_msg_source_0, out, epy_block_0, in]

metadata:
  file_format: 1
  grc_version: v3.10.11.0-1-gee27d6f3
