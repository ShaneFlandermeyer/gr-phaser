options:
  parameters:
    generate_options: qt_gui
    id: phaser_zmq_host
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 10e9
  states: {}
- name: rpi_ip
  id: variable
  parameters:
    value: '"169.254.227.151"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: phaser_sum_beams_0
  id: phaser_sum_beams
  parameters:
    beam_key_pattern: phaser:beam[0-9]+
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    srate: samp_rate
    type: msg_complex
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: f"tcp://{rpi_ip}:3001"
    timeout: '100'
  states: {}

connections:
- [phaser_sum_beams_0, out, qtgui_time_sink_x_0, in]
- [zeromq_pull_msg_source_0, out, phaser_sum_beams_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
