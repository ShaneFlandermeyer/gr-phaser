options:
  parameters:
    generate_options: qt_gui
    id: pluto_pulsed
    output_language: python
    run_command: '{python} {filename}'
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 2/3*samp_rate
  states: {}
- name: ncpi
  id: variable
  parameters:
    value: '128'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: phaser_pluto_radar_0
  id: phaser_pluto_radar
  parameters:
    burst_repetition_interval: 1/10e3
    burst_start_sample: '-1'
    burst_stop_sample: '-1'
    center_freq: 2.1e9
    num_bursts: '128'
    rx_gain: '40'
    rx_offset_samples: '117'
    sample_rate: samp_rate
    tx_cyclic_buffer: 'True'
    tx_gain: '0'
    uri: ip:pluto.local
  states: {}
- name: plasma_lfm_source_0
  id: plasma_lfm_source
  parameters:
    bandwidth: bandwidth
    bandwidth_key: radar:bandwidth
    duration_key: radar:duration
    label_key: core:label
    prf: '0'
    prf_key: radar:prf
    pulse_width: '20e-6'
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    start_freq: '-bandwidth/2'
    start_freq_key: radar:start_freq
  states: {}
- name: plasma_pulse_doppler_0
  id: plasma_pulse_doppler
  parameters:
    backend: plasma.Device.DEFAULT
    depth: '1'
    doppler_fft_size_key: doppler_fft_size
    n_pulse_cpi: ncpi
    nfft: ncpi
  states: {state: disabled}
- name: plasma_range_doppler_sink_0
  id: plasma_range_doppler_sink
  parameters:
    center_freq: 10e9
    center_freq_key: core:frequency
    depth: '1'
    detection_indices_key: detection_indices
    dynamic_range: '60'
    dynamic_range_key: dynamic_range
    n_matrix_col_key: n_matrix_col
    nrow: ncpi
    prf_key: pluto:prf
    pulsewidth_key: radar:duration
    samp_rate: samp_rate
    samp_rate_key: core:sample_rate
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    srate: samp_rate
    type: msg_complex
  states: {}

connections:
- [phaser_pluto_radar_0, out, plasma_pulse_doppler_0, rx]
- [phaser_pluto_radar_0, out, qtgui_time_sink_x_0, in]
- [plasma_lfm_source_0, out, phaser_pluto_radar_0, in]
- [plasma_lfm_source_0, out, plasma_pulse_doppler_0, tx]
- [plasma_pulse_doppler_0, out, plasma_range_doppler_sink_0, in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-522-g1aa42876
